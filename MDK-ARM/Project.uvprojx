# Keil uVision project Project.uvprojx, settings and files
target STM32F103_DevBeta (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: DevBeta_STM32F103 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --cpp11
  c include: ..\\CMSIS\\Include;..\\CMSIS\\Device\\STM32F1xx\\Include;..\\CMSIS\\Device\\STM32F1xx;..\\Startup;..\\User;..\\Application\\Sensors;..\\Drivers\\USART;..\\Drivers\\SPI;..\\Drivers\\DMA;..\\Drivers\\Timer;..\\Drivers\\PWM;..\\Drivers\\I2C;..\\Hardware\\LCD;..\\Hardware\\LED;..\\Hardware\\KEY;..\\Hardware\\Encoder;..\\Hardware\\DHT11;..\\Hardware\\BMP280;..\\Hardware\\CS100A;..\\Hardware\\Watchdog;..\\Drivers\\STM32F1xx_HAL_Driver\\Inc;..\\Drivers\\STM32F1xx_HAL_Driver\\Inc\\Legacy;..\\Drivers\\STM32F1xx_HAL_Driver\\Src;..\\Astra\\hal;..\\Astra\\astra;..\\Astra\\astra\\pages;..\\Astra\\astra\\config;..\\Astra\\astra\\ui;..\\Astra\\astra\\ui\\element\\page
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../Startup/: startup_stm32f103xb.s
  group CMSIS
    ../CMSIS/Device/STM32F1xx/: system_stm32f1xx.c
  group HAL Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c stm32f1xx_hal_dma.c stm32f1xx_hal_i2c.c
  group Drivers
    ../Drivers/USART/: usart.c
    ../Drivers/SPI/: spi.c
    ../Drivers/DMA/: dma.c
    ../Drivers/Timer/: timer.c
    ../Drivers/I2C/: i2c.c
    ../Drivers/PWM/: pwm.c
  group Hardware
    ../Hardware/LCD/: lcd.c
    ../Hardware/LED/: led.c
    ../Hardware/KEY/: key.c
    ../Hardware/Encoder/: encoder.c
    ../Hardware/DHT11/: dht11.c dht11_stm32f103.c
    ../Hardware/Watchdog/: watchdog.c
    ../Hardware/BMP280/: bmp280.c
    ../Hardware/CS100A/: cs100a.c cs100a_stm32f103.c
  group Application
    ../Application/Sensors/: sensor_runtime.c dht11_sensor.c bmp280_sensor.c cs100a_sensor.c
  group User
    ../User/: main.cpp bsp_init.c
  group Astra
    ../Astra/hal/: hal.cpp hal_port.cpp
    ../Astra/astra/pages/: display_page.cpp about_page.cpp sensor_pages.cpp pwm_page.cpp
    ../Astra/astra/: status_bar.cpp astra_rocket.cpp
    ../Astra/astra/ui/: launcher.cpp
    ../Astra/astra/ui/element/page/: item.cpp
software components: CMSIS:CORE 4.3.0
